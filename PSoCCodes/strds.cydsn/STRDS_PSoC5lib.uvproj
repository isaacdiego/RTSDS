# Keil uVision project STRDS_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: STRDS_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h SAIDA_VEL_aliases.h SAIDA_VEL.c SAIDA_VEL.h LCD.c LCD.h LCD_PM.c MSG_1.c MSG_1.h MSG_1_PM.c MAD_1.c MAD_1.h MAD_1_PM.c MAD_1_INT.c ENT_TORQUE_aliases.h ENT_TORQUE.c ENT_TORQUE.h isr_1.c isr_1.h Timer.c Timer.h Timer_PM.c timer_clock.c timer_clock.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h MAD_1_theACLK.c MAD_1_theACLK.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h MAD_2.c MAD_2.h MAD_2_INT.c MAD_2_PM.c ENT_ALFA_aliases.h ENT_ALFA.c ENT_ALFA.h MAD_2_IRQ.c MAD_2_IRQ.h MAD_2_theACLK.c MAD_2_theACLK.h MAD_2_Bypass_aliases.h MAD_2_Bypass.c MAD_2_Bypass.h MAD_1_IRQ.c MAD_1_IRQ.h MAD_1_Bypass_aliases.h MAD_1_Bypass.c MAD_1_Bypass.h PINO_PROCESSAMENTO_aliases.h PINO_PROCESSAMENTO.c PINO_PROCESSAMENTO.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: STRDS_PSoC5lib (library)
